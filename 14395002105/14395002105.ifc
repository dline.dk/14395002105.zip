Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-08T07:37:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 08 07:37:37 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{4812A83F-EDC6-41FA-A072-08A7EDFBF30F}\ifc * Database version: 5507 * Database creation date: Wed Nov 08 07:37:36 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 08 07:37:36 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 08 07:37:36 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_PullHandles_Flush_Oval_50x120, 14395002105b:dline_Hardware_PullHandles_Flush_Oval_50x120:194153
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - ClassificationGradesMinimumCategoryOfUse: n/a; ClassificationGradesMinimumCorrosionResistance: n/a; ClassificationGradesMinimumDoorMass: n/a; ClassificationGradesMinimumDurability: n/a; ClassificationGradesMinimumFireResistance: n/a; ClassificationGradesMinimumSafety: n/a; ClassificationGradesMinimumSecurity: n/a; ClassificationGradesMinimumTypeOfOperation: n/a
Type - Dimensions - c-c: 52 mm; CupDiameter: 41 mm; CupHeight: 10 mm; GripDiameter: 28 mm; Height: 0 mm; HoleDiameter: 42 mm; HoleHeight: 11 mm; Length: 102 mm; LipDiameter: 50 mm; LipThickness: 3 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_PullHandles_Flush_Oval_50x120; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Door lever handle sets; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-60/365; NBSTypeID: n/a; OmniclassCode: 22-08 71 00; OmniclassDescription: Door Hardware; ProductFamily: Hardware; ProductGroup: Pull handles; ProductInformation: http://dline.com/product/knud-holscher-collection-flush-pull-oval/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_item=50-x-102-mm-satin-finish#; ProductionCountry: Lithuania; ProductSKU: 14395002105; Revision: n/a; Uniclass2015Code: Pr_30_36_59_64; Uniclass2015Title: Pull handles; Uniclass2015Version: Products v1.5; UNSPSCCode: 31162801; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Oval flush pull handle; Manufacturer: info@dline.com; Type Mark: 22; Type Name: dline_Hardware_PullHandles_Flush_Oval_50x120
Type - Materials and Finishes - MainMaterial: AISI 316
Type - Other - AccessibilityPerformance: n/a; AssetType: fixed; Category: Pr_30_36_59_64:Pull handles; CodePerformance: n/a; Color: n/a; Constituents: Pull handle, toilet indicator; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14395002105b; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 316 stainless steel; ModelNumber: n/a; ModelReference: 45-25-60/365; Name: dline_Hardware_PullHandles_Flush_Oval_50x120; ReplacementCost: n/a; Shape: n/a; Size: 102 x 52 x 10 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 36.4117 mm; OverallWidth: 50 mm
Pset_DoorCommon - Reference: n/a; IsExternal: no; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: 45-25-60/365; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.00930864 m2; Volume: 0.0000330168 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Doors; Family: 14395002105b: dline_Hardware_PullHandles_Flush_Oval_50x120; Family and Type: 14395002105b: dline_Hardware_PullHandles_Flush_Oval_50x120; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14395002105b: dline_Hardware_PullHandles_Flush_Oval_50x120; Type Id: 14395002105b: dline_Hardware_PullHandles_Flush_Oval_50x120; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
